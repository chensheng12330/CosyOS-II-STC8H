# Keil uVision project CosyOS-II-STC8H.uvproj, settings and files
target CosyOS-II-STC8H (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: CosyOS-II-STC8H +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\STC8H
  link misc: NOOVERLAY
  group STC8H
    ./STC8H/: STC8H.H
  group System
    ./System/: os_api.c os_api.h os_base.h os_debug.c os_def.h os_handler.c os_hook.h os_link.h os_main.c os_redef.h os_starter.c os_sysidle.c os_task.h os_taskmgr.c os_timing.c os_var.c os_var.h sv_create.h sv_int_loc.c sv_int_loc.h sv_int_pend_fifo.c sv_int_pend_fifo.h sv_int_pend_flag.c sv_int_pend_flag.h sv_task.c sv_task.h sv_tick.c sv_tick.h ur_api.h
  group Config
    ./Config/: mcucfg_8051.h mcucfg_8051.inc syscfg.h
  group Hook
    ./Hook/: gvar_hook.c idle_hook.c init_hook.c pendsv_hook.c start_hook.c tick_hook.c
  group Port
    ./Port/: port_8051.c port_8051.h port_8051s.s startup_8051.s
  group User
    ./User/: typedef.h Taskmgr.c
  group Test
    ./Test/: readme.txt test.h
  group test_xwtb
    ./Test/test_xwtb/: led.c test_xwtb_ressus.c test_xwtb_clrblk.c test_xwtb_bin.c test_xwtb_sem.c test_xwtb_group.c test_xwtb_fetion.c test_xwtb_taskmsg.c test_xwtb_mailbox.c test_xwtb_queue.c
  group test_int0delay
    ./Test/test_int0delay/: test_int0delay.c
  group test_malloc
    ./Test/test_malloc/: hmacmd5.c hmacmd5.h test_malloc.c
  group test_c51
    ./Test/test_c51/: test_c51xbp.c
